Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:38:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:38:26 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{CB4585C8-C7BC-4658-84B1-2509E6652069}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:38:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:38:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:38:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2308CU_Медь, КНС_ДержательПруткаНаВодостоке_DKC:ND2308CU_Медь:967796
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2308CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2308CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2308CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • крепление токоотводов к водосточным желобам. Характеристики: • болтовое крепление проводника; • позволяет прокладывать проводник как поперек, так и вдоль водостока.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2308_Горячеоцинкованная сталь, КНС_ДержательПруткаНаВодостоке_DKC:ND2308_Горячеоцинкованная сталь:967789
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2308_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2308; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2308/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • крепление токоотводов к водосточным желобам. Характеристики: • болтовое крепление проводника; • позволяет прокладывать проводник как поперек, так и вдоль водостока.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2309CU_Медь, КНС_ДержательПруткаНаВодостоке_DKC:ND2309CU_Медь:967798
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2309CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2309CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2309CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • крепление токоотводов к водосточным желобам. Характеристики: • болтовое крепление проводника; • позволяет прокладывать проводник как поперек, так и вдоль водостока.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2309_Горячеоцинкованная сталь, КНС_ДержательПруткаНаВодостоке_DKC:ND2309_Горячеоцинкованная сталь:967797
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2309_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2309; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2309/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • крепление токоотводов к водосточным желобам. Характеристики: • болтовое крепление проводника; • позволяет прокладывать проводник как поперек, так и вдоль водостока.; Комментарии к типоразмеру: Держатели Jupiter
