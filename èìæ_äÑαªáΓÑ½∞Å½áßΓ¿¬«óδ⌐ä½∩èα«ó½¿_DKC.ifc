Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:03:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:03:29 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DEDD7ACD-9531-4151-8219-A9F8A6B8030C}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:03:28 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:03:29 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:03:29 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2104_Полипропилен, КНС_ДержательПластиковыйДляКровли_DKC:ND2104_Полипропилен:956240
In: Этаж 01
Type - Material: DKC_Полипропилен
Pset_BuildingElementProxyCommon - Reference: ND2104_Полипропилен
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2104; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2104/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на кровле при помощи клея или битумных полос. Характеристики: • отщелкивающееся основание для приклеивания; • вращающийся замок позволяет произвести подвод прутка под произвольным углом.; Комментарии к типоразмеру: Держатели Jupiter
