Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:17:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:17:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A0F2D1E6-EFE1-4139-B5DB-60061670E0BE}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:17:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:17:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:17:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_612157 | Механизмы Молниезащита_Пруток 4
2 x OutPort_660576 | Механизмы Молниезащита_Пруток 4
InPort_612159 | Механизмы Молниезащита_Пруток 4
InPort_612163 | Механизмы Молниезащита_Пруток 7
2 x OutPort_660581 | Механизмы Молниезащита_Пруток 7
InPort_612165 | Механизмы Молниезащита_Пруток 7

# IfcFlowFitting: Стандарт (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Стандарт
Name (КНС_Поворот_Пруток_Неспецифицируемое_DKC:Стандарт:...) | Group
660576 | Механизмы Молниезащита_Пруток 4
660581 | Механизмы Молниезащита_Пруток 7

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Медь_8/10мм_DKC (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Медь_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Медь_8/10мм_DKC:...) | Group
612157 | Механизмы Молниезащита_Пруток 4
612159 | Механизмы Молниезащита_Пруток 4
612163 | Механизмы Молниезащита_Пруток 7
612165 | Механизмы Молниезащита_Пруток 7
