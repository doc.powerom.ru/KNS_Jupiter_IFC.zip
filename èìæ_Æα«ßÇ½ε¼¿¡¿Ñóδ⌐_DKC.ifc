Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:23:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:23:21 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{8BB634A5-0A94-460E-8C49-1ED5D5488244}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:23:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:23:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:23:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowSegment: Гибкий воздуховод круглого сечения:КНС_ТросАлюминиевый_DKC, Гибкий воздуховод круглого сечения:КНС_ТросАлюминиевый_DKC:679610
In: Этаж 01
Type - PredefinedType: FLEXIBLESEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_ТросАлюминиевый_DKC
