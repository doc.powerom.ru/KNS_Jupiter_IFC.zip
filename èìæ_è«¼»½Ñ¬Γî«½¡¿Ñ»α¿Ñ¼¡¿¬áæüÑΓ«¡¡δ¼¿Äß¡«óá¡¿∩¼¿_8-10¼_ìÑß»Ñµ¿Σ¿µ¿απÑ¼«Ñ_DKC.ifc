Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:12:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:12:00 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{1F902CED-3F5B-4239-8831-E3D6D85B8270}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:11:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:12:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:12:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG6008_8м, КНС_ДополнительныйКомплектДляМачты_DKC:NG6008_8м:736691
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NG6008_8м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NG6008; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6008/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000490; Описание: Назначение: дополнительные комплектующие для мачты • кронштейн NL0200 для стержней 1–4 м;; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NG6009_9м, КНС_ДополнительныйКомплектДляМачты_DKC:NG6009_9м:736772
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NG6009_9м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NG6009; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6009/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000490; Описание: Назначение: дополнительные комплектующие для мачты • кронштейн NL0200 для стержней 1–4 м;; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NG6010_10м, КНС_ДополнительныйКомплектДляМачты_DKC:NG6010_10м:736812
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NG6010_10м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NG6010; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6010/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000490; Описание: Назначение: дополнительные комплектующие для мачты • кронштейн NL0200 для стержней 1–4 м;; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NG6606_Горячеоцинкованная сталь (3)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG6606_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG6606; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6606/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • подключение молниеприемной сетки или токоотводов к молниеприемному стержню.; Комментарии к типоразмеру: Молниеприемники Jupiter
Name (КНС_СоединительПроводникаДляМолниеприемника_DKC:NG6606_Горячеоцинкованная сталь:...)
736654
736761
736801

# IfcBuildingElementProxy: NG6607_Алюминий (3)
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NG6607_Алюминий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG6607; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6607/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: ● подключение ESE молниеприемника к мачтам 5–6 метров. Характеристики: ● ввинчивается в основание ESE молниеприемника и крепится к мачтам 5–6 метров.; Комментарии к типоразмеру: Jupiter Элементы для монтажа
Name (КНС_СоединительESEМолниеприемникМачта_DKC:NG6607_Алюминий:...)
1153562
1153564
1153566

# IfcBuildingElementProxy: NI0015_Нержавеющая сталь V4A (3)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0015_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0015; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0015/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники
Name (КНС_ESEМолниеприемник_DKC:NI0015_Нержавеющая сталь V4A:...)
1153563
1153565
1153567

# IfcBuildingElementProxy: NL0500_Бетон_40кг (15)
In: Этаж 01
Type - Material: DKC_Бетон
Pset_BuildingElementProxyCommon - Reference: NL0500_Бетон_40кг
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL0500; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL0500/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Описание: Назначение • установка стержневых молниеприемников на плоских горизонтальных поверхностях. Особенности • содержит две точки подключения с резьбой М16 для ввинчивания молниеприемного стержня и специального соединителя; • точки подключения соединены металлической пластиной внутри основания; Комментарии к типоразмеру: Молниеприемники Jupiter
Name (КНС_ОсновниеБетонное_DKC:NL0500_Бетон_40кг:...)
736649
736686
736687
736688
736689
736759
736767
736768
736769
736770
736799
736807
736808
736809
736810

# IfcBuildingElementProxy: NL0900_Горячеоцинкованная сталь (18)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NL0900_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Комментарии к типоразмеру: Молниеприемники Jupiter
Name | ADSK_Код изделия | ADSK_URL страницы изделия | Описание
КНС_ОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736650 | NL0900 | https://www.dkc.ru/ru/catalog/571/NL0900/ | Назначение: • установка молниеприемных мачт длиной 8-10 метров.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736681 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736682 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736683 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736684 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736685 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_ОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736760 | NL0900 | https://www.dkc.ru/ru/catalog/571/NL0900/ | Назначение: • установка молниеприемных мачт длиной 8-10 метров.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736762 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736763 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736764 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736765 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736766 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_ОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736800 | NL0900 | https://www.dkc.ru/ru/catalog/571/NL0900/ | Назначение: • установка молниеприемных мачт длиной 8-10 метров.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736802 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736803 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736804 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736805 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.
КНС_УдлинительНаОснованиеДляМолниеприемнойМачты_DKC:NL0900_Горячеоцинкованная сталь:736806 | NL0910 | https://www.dkc.ru/ru/catalog/571/NL0910/ | Назначение: Удлинители на основание необходимы для монтажа молниеприемных мачт 8-10 м. Удлинители ввинчиваются в пятиногу NL0900 и фиксируются на бетонных основаниях.

# IfcBuildingElementProxy: NL1100_СтальНержавеющая_10м, КНС_МачтаМолниеприемная_DKC:NL1100_СтальНержавеющая_10м:736811
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL1100_СтальНержавеющая_10м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL1100; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL1100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL8000_СтальНержавеющая_8м, КНС_МачтаМолниеприемная_DKC:NL8000_СтальНержавеющая_8м:736690
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL8000_СтальНержавеющая_8м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL8000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL8000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL9000_СтальНержавеющая_9м, КНС_МачтаМолниеприемная_DKC:NL9000_СтальНержавеющая_9м:736771
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL9000_СтальНержавеющая_9м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL9000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL9000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter
