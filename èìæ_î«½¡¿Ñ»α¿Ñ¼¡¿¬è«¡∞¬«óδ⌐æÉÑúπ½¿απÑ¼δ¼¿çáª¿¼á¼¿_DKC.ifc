Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:10:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:10:07 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{D7AFAFEB-DA14-4F95-845C-E6188CD9315C}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:10:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:10:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:10:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL5100_Алюминий_1м, КНС_МолниеприемникКоньковыйСРегулируемымиЗажимами_DKC:NL5100_Алюминий_1м:694037
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL5100_Алюминий_1м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5100; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на круглый конек кровли.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL5150_Алюминий_1.5м, КНС_МолниеприемникКоньковыйСРегулируемымиЗажимами_DKC:NL5150_Алюминий_1.5м:694150
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL5150_Алюминий_1.5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5150; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5150/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на круглый конек кровли.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL5200_Алюминий_2м, КНС_МолниеприемникКоньковыйСРегулируемымиЗажимами_DKC:NL5200_Алюминий_2м:694158
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL5200_Алюминий_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5200; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5200/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на круглый конек кровли.; Комментарии к типоразмеру: Молниеприемники Jupiter
