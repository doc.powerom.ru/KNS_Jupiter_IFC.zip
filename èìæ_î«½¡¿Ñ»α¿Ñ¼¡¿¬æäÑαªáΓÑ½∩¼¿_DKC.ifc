Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:12:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:12:49 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{D037545C-6900-4E1E-BA72-68CBA0A7353E}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:12:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:12:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:12:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL7100CU_Медь_1м, КНС_МолниеприемникСДержателями_DKC:NL7100CU_Медь_1м:976358
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL7100CU_Медь_1м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7100CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7100CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7100_Алюминий_1м, КНС_МолниеприемникСДержателями_DKC:NL7100_Алюминий_1м:976353
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL7100_Алюминий_1м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7100; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7150CU_Медь_1.5м, КНС_МолниеприемникСДержателями_DKC:NL7150CU_Медь_1.5м:976371
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL7150CU_Медь_1.5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7150CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7150CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7150_Алюминий_1.5м, КНС_МолниеприемникСДержателями_DKC:NL7150_Алюминий_1.5м:976359
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL7150_Алюминий_1.5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7150; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7150/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7200CU_Медь_2м, КНС_МолниеприемникСДержателями_DKC:NL7200CU_Медь_2м:976405
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL7200CU_Медь_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7200CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7200CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7200_Алюминий_2м, КНС_МолниеприемникСДержателями_DKC:NL7200_Алюминий_2м:976372
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL7200_Алюминий_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7200; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7200/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7300CU_Медь_3м, КНС_МолниеприемникСДержателями_DKC:NL7300CU_Медь_3м:976407
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL7300CU_Медь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7300CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7300CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7300_Алюминий_3м, КНС_МолниеприемникСДержателями_DKC:NL7300_Алюминий_3м:976406
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL7300_Алюминий_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7300; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7300/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на вертикальные поверхности (стена, вытяжная труба). Характеристики: • в комплекте имеются два держателя с дюбелями и установочный соединитель для подключения токоотвода; • расстояние стержня от несущей поверхности – 75 мм; • возможно подключение прутка диаметром 8 или 10 мм или полосы 25х4 мм.; Комментарии к типоразмеру: Молниеприемники Jupiter
