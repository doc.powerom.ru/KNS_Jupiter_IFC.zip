Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:20:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:20:11 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{10D52EE0-75EE-4E25-9876-5FD9601183F4}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:20:11 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:20:11 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:20:11 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Изолированный токоотвод_23мм_DKC, Воздуховод круглого сечения:КНС_Изолированный токоотвод_23мм_DKC:998517
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Изолированный токоотвод_23мм_DKC
