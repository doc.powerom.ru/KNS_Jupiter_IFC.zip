Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:09:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:09:45 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{56F4929D-6AEF-4D08-9CC9-4DC96AA36FDD}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:09:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:09:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:09:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL1100_СтальНержавеющая_10м, КНС_МачтаМолниеприемная_DKC:NL1100_СтальНержавеющая_10м:692205
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL1100_СтальНержавеющая_10м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL1100; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL1100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL5000CU_Медь_5м, КНС_МачтаМолниеприемная_DKC:NL5000CU_Медь_5м:692072
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL5000CU_Медь_5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5000CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5000CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL5000_СтальНержавеющая_5м, КНС_МачтаМолниеприемная_DKC:NL5000_СтальНержавеющая_5м:692007
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL5000_СтальНержавеющая_5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6000CU_Медь_6м, КНС_МачтаМолниеприемная_DKC:NL6000CU_Медь_6м:692088
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL6000CU_Медь_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6000CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6000CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6000_СтальНержавеющая_6м, КНС_МачтаМолниеприемная_DKC:NL6000_СтальНержавеющая_6м:692080
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL6000_СтальНержавеющая_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7000_СтальНержавеющая_7м, КНС_МачтаМолниеприемная_DKC:NL7000_СтальНержавеющая_7м:692166
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL7000_СтальНержавеющая_7м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL8000_СтальНержавеющая_8м, КНС_МачтаМолниеприемная_DKC:NL8000_СтальНержавеющая_8м:692185
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL8000_СтальНержавеющая_8м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL8000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL8000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL9000_СтальНержавеющая_9м, КНС_МачтаМолниеприемная_DKC:NL9000_СтальНержавеющая_9м:692195
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL9000_СтальНержавеющая_9м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NL9000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL9000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter
