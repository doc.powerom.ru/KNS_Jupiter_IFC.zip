Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:15:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:15:30 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A788C5CF-2C5A-4F70-A24D-212C4AEFB9CE}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:15:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:15:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:15:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE1304_Латунь_D16, КНС_МуфтаСоединительная_DKC:NE1304_Латунь_D16:989422
In: Этаж 01
Type - Material: DKC_Латунь
Pset_BuildingElementProxyCommon - Reference: NE1304_Латунь_D16
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1304; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1304/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001465; Описание: Назначение: • соединение стержней вертикального заземлителя друг с другом, подключение соединителя.; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1306_Латунь_D14.2, КНС_МуфтаСоединительная_DKC:NE1306_Латунь_D14.2:989588
In: Этаж 01
Type - Material: DKC_Латунь
Pset_BuildingElementProxyCommon - Reference: NE1306_Латунь_D14.2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1306; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1306/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001465; Описание: Назначение: • соединение стержней вертикального заземлителя друг с другом, подключение соединителя.; Комментарии к типоразмеру: Заземление Jupiter
