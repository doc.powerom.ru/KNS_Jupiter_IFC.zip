Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:15:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:15:13 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{FC630E32-1635-4960-951A-9BDD199DE7A9}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:15:11 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:15:11 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:15:11 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_612041 | Механизмы Молниезащита_Пруток 1
2 x OutPort_660442 | Механизмы Молниезащита_Пруток 1
InPort_612056 | Механизмы Молниезащита_Пруток 1
InPort_612078 | Механизмы Молниезащита_Пруток 2
2 x OutPort_660453 | Механизмы Молниезащита_Пруток 2
InPort_612080 | Механизмы Молниезащита_Пруток 2

# IfcFlowFitting: Стандарт (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Стандарт
Name (КНС_Поворот_Пруток_Неспецифицируемое_DKC:Стандарт:...) | Group
660442 | Механизмы Молниезащита_Пруток 1
660453 | Механизмы Молниезащита_Пруток 2

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Горячеоцинкованный_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC:...) | Group
612041 | Механизмы Молниезащита_Пруток 1
612056 | Механизмы Молниезащита_Пруток 1
612078 | Механизмы Молниезащита_Пруток 2
612080 | Механизмы Молниезащита_Пруток 2
