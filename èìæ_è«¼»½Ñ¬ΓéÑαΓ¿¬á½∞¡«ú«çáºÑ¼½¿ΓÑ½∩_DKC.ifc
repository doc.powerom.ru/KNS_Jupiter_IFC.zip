Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:13:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:13:54 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F6C130D0-6F51-482B-9FB3-FBDA77761A1C}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:13:54 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:13:54 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:13:54 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE1103_Горячеоцинкованная сталь_3м, КНС_КомплектВертикальногоЗаземлителя_DKC:NE1103_Горячеоцинкованная сталь_3м:983515
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NE1103_Горячеоцинкованная сталь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NE1103; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1103/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002674; Описание: Назначение • вертикальное заземление. Тип упаковки • стретч-пленка; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1104_Горячеоцинкованная сталь_3м, КНС_КомплектВертикальногоЗаземлителя_DKC:NE1104_Горячеоцинкованная сталь_3м:983706
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Латунь
Pset_BuildingElementProxyCommon - Reference: NE1104_Горячеоцинкованная сталь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NE1104; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1104/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002674; Описание: Назначение • вертикальное заземление. Тип упаковки • стретч-пленка; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1114CC_Омеднённая сталь_3м, КНС_КомплектВертикальногоЗаземлителя_DKC:NE1114CC_Омеднённая сталь_3м:983817
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Латунь, DKC_Сталь_Нержавеющая_Омедненная, DKC_Сталь
Pset_BuildingElementProxyCommon - Reference: NE1114CC_Омеднённая сталь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NE1114CC; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1114CC/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002674; Описание: Назначение • вертикальное заземление. Тип упаковки • стретч-пленка; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1150_Горячеоцинкованная сталь_6м, КНС_КомплектВертикальногоЗаземлителя_DKC:NE1150_Горячеоцинкованная сталь_6м:983827
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NE1150_Горячеоцинкованная сталь_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NE1150; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1150/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002674; Описание: Назначение • вертикальное заземление. Тип упаковки • коробка с ручкой.; Комментарии к типоразмеру: Заземление Jupiter
