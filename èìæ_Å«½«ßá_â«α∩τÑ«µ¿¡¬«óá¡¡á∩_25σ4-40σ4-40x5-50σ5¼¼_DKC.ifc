Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:25:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:25:15 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{84EA0DF7-979F-4FBB-8144-F5D246AF29F2}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:25:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:25:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:25:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_615588 | Механизмы Молниезащита_Полоса 51
2 x OutPort_615606 | Механизмы Молниезащита_Полоса 51
InPort_615604 | Механизмы Молниезащита_Полоса 51
InPort_615783 | Механизмы Молниезащита_Полоса 27
2 x OutPort_615785 | Механизмы Молниезащита_Полоса 27
InPort_615784 | Механизмы Молниезащита_Полоса 27
InPort_615797 | Механизмы Молниезащита_Полоса 28
2 x OutPort_615799 | Механизмы Молниезащита_Полоса 28
InPort_615798 | Механизмы Молниезащита_Полоса 28
InPort_615811 | Механизмы Молниезащита_Полоса 29
2 x OutPort_615813 | Механизмы Молниезащита_Полоса 29
InPort_615812 | Механизмы Молниезащита_Полоса 29

# IfcFlowFitting: Изгиб полосы (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Изгиб полосы
Name (КНС_Поворот_Полоса_Неспецифицируемое_DKC:Изгиб полосы:...) | Group
615606 | Механизмы Молниезащита_Полоса 51
615785 | Механизмы Молниезащита_Полоса 27
615799 | Механизмы Молниезащита_Полоса 28
615813 | Механизмы Молниезащита_Полоса 29

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC:...) | Group
615588 | Механизмы Молниезащита_Полоса 51
615604 | Механизмы Молниезащита_Полоса 51
615783 | Механизмы Молниезащита_Полоса 27
615784 | Механизмы Молниезащита_Полоса 27
615797 | Механизмы Молниезащита_Полоса 28
615798 | Механизмы Молниезащита_Полоса 28
615811 | Механизмы Молниезащита_Полоса 29
615812 | Механизмы Молниезащита_Полоса 29
