Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:27:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:27:25 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{7990D10C-F6F4-4E19-AF05-89BEA057EFF6}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:27:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:27:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:27:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NI0015_Нержавеющая сталь V4A, КНС_ESEМолниеприемник_DKC:NI0015_Нержавеющая сталь V4A:1018905
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0015_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0015; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0015/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники

# IfcBuildingElementProxy: NI0030_Нержавеющая сталь V4A, КНС_ESEМолниеприемник_DKC:NI0030_Нержавеющая сталь V4A:1019080
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0030_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0030; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0030/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники

# IfcBuildingElementProxy: NI0045_Нержавеющая сталь V4A, КНС_ESEМолниеприемник_DKC:NI0045_Нержавеющая сталь V4A:1019090
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0045_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0045; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0045/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники

# IfcBuildingElementProxy: NI0060_Нержавеющая сталь V4A, КНС_ESEМолниеприемник_DKC:NI0060_Нержавеющая сталь V4A:1019115
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0060_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0060; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0060/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники
