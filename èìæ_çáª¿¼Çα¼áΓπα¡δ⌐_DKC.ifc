Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:02:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:02:51 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B133402F-842E-47F2-9320-9DF0C3CE4F62}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:02:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:02:51 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:02:51 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2003_Гальванически оцинкованнная сталь, КНС_ЗажимАрматурный_DKC:ND2003_Гальванически оцинкованнная сталь:955152
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: ND2003_Гальванически оцинкованнная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • подключение полосы и прутка к стальной арматуре. Характеристики: • надежное болтовое крепление; • максимальная толщина полосы – 5 мм; • соединение точки заземления NE1003 с арматурой с помощью зажима ND2004.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2004_Гальванически оцинкованнная сталь_С наконечником, КНС_ЗажимАрматурный_DKC:ND2004_Гальванически оцинкованнная сталь_С наконечником:955153
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: ND2004_Гальванически оцинкованнная сталь_С наконечником
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2004; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2004/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • подключение полосы и прутка к стальной арматуре. Характеристики: • надежное болтовое крепление; • максимальная толщина полосы – 5 мм; • соединение точки заземления NE1003 с арматурой с помощью зажима ND2004.; Комментарии к типоразмеру: Держатели Jupiter
