Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:36:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:36:58 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9DD06287-3EA7-4588-AA7D-4518298F235F}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:36:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:36:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:36:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2115_Нержавеющая сталь, КНС_ДержательБезболтовой_DKC:ND2115_Нержавеющая сталь:958761
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: ND2115_Нержавеющая сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2115; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2115/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: ● крепление молниеприемной сетки на фасадах и кровле при помощи саморезов. Характеристики: ● отщелкивающееся основание позволяет закрепить пруток как перпендикулярно, так и параллельно краю крыши; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter
