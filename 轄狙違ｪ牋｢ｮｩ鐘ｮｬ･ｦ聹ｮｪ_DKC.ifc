Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:28:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:28:23 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4A0A8960-9509-4519-8B68-595FEE9037A1}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:28:23 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:28:23 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:28:23 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NX0001, КНС_ИскровойПромежуток_DKC:NX0001:1020941
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь
Pset_BuildingElementProxyCommon - Reference: NX0001
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX0001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX0001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000510; Описание: Данное устройство позволяет произвести электрическое соединение нормально разделенных металлоконструкций. Разрядник компенсирует разницу в потенциалах, возникающую между двумя электродами, при ударе молнии. Это также позволяет избежать коррозии, которая может появиться в месте соединения двух удаленных контуров заземления. Для подключения рекомендуется применять соединитель NG3103; Комментарии к типоразмеру: Jupiter УЗИП класс I
