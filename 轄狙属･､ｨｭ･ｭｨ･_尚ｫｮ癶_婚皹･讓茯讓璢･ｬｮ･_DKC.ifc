Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:04:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:04:16 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{2A3A292C-E2C7-4E98-BF2D-11EE23F4479B}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:04:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:04:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:04:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3105CU_Медь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105CU_Медь_80х70 мм:761940
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3105CU_Медь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:761905
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106CU_Медь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106CU_Медь_100х100 мм:762034
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3106CU_Медь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:761984
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_624561 | Механизмы Молниезащита_Полоса 13
2 x OutPort_761904 | Механизмы Молниезащита_Полоса 13
InPort_626834 | Механизмы Молниезащита_Полоса 12
2 x OutPort_761939 | Механизмы Молниезащита_Полоса 12
InPort_626849 | Механизмы Молниезащита_Полоса 15
2 x OutPort_761983 | Механизмы Молниезащита_Полоса 15
InPort_626864 | Механизмы Молниезащита_Полоса 16
2 x OutPort_762033 | Механизмы Молниезащита_Полоса 16
InPort_761903 | Механизмы Молниезащита_Полоса 13
InPort_761938 | Механизмы Молниезащита_Полоса 12
InPort_761982 | Механизмы Молниезащита_Полоса 15
InPort_762032 | Механизмы Молниезащита_Полоса 16

# IfcFlowFitting: NG3105CU_Медь_80х70 мм, КНС_Соединение_Полоса_Неспецифицируемое_DKC:NG3105CU_Медь_80х70 мм:761939
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105CU_Медь_80х70 мм
Group: Механизмы Молниезащита_Полоса 12

# IfcFlowFitting: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_Соединение_Полоса_Неспецифицируемое_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:761904
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Group: Механизмы Молниезащита_Полоса 13

# IfcFlowFitting: NG3106CU_Медь_100х100 мм, КНС_Соединение_Полоса_Неспецифицируемое_DKC:NG3106CU_Медь_100х100 мм:762033
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106CU_Медь_100х100 мм
Group: Механизмы Молниезащита_Полоса 16

# IfcFlowFitting: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_Соединение_Полоса_Неспецифицируемое_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:761983
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Group: Механизмы Молниезащита_Полоса 15

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC:...) | Group
624561 | Механизмы Молниезащита_Полоса 13
626834 | Механизмы Молниезащита_Полоса 12
626849 | Механизмы Молниезащита_Полоса 15
626864 | Механизмы Молниезащита_Полоса 16
761903 | Механизмы Молниезащита_Полоса 13
761938 | Механизмы Молниезащита_Полоса 12
761982 | Механизмы Молниезащита_Полоса 15
762032 | Механизмы Молниезащита_Полоса 16
