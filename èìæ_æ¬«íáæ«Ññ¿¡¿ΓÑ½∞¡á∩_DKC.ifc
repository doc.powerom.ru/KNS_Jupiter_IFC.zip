Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:17:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:17:44 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{713E375B-235E-482A-B0AA-F9B853568AB8}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:17:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:17:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:17:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NA1201_Алюминий, КНС_СкобаСоединительная_DKC:NA1201_Алюминий:997305
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NA1201_Алюминий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NA1201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NA1201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • подключение и соединение металлических элементов. Характеристики: • 1 крепежное отверстие диаметром 9 мм; • 8 крепежных отверстий диаметром 5,2 мм; • 4 крепежных отверстия диаметром 6,9 мм.; Комментарии к типоразмеру: Аксессуары Jupiter

# IfcOpeningElement: Opening (13)
In: Этаж 01
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Name (КНС_СкобаСоединительная_DKC:NA1201_Алюминий:997305:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
