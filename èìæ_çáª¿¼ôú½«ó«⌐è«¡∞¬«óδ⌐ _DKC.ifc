Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:06:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:06:20 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{18EC6E29-B7AE-4D8A-867B-C5428FFDA1C6}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:06:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:06:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:06:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2201CU_Медь_150 мм, КНС_ЗажимУгловойКоньковый _DKC:ND2201CU_Медь_150 мм:959885
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2201CU_Медь_150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2201CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2201CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2201_Горячеоцинкованная сталь_150 мм, КНС_ЗажимУгловойКоньковый _DKC:ND2201_Горячеоцинкованная сталь_150 мм:959878
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2201_Горячеоцинкованная сталь_150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2202CU_Медь_100 мм, КНС_ЗажимУгловойКоньковый _DKC:ND2202CU_Медь_100 мм:959887
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2202CU_Медь_100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2202CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2202CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2202_Горячеоцинкованная сталь_100 мм, КНС_ЗажимУгловойКоньковый _DKC:ND2202_Горячеоцинкованная сталь_100 мм:959886
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2202_Горячеоцинкованная сталь_100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2202; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2202/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter
