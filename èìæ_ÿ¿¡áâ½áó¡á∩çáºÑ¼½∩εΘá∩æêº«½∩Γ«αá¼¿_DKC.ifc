Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:17:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:17:05 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{994B8965-6577-49CD-9E77-9F684C4B8EA1}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:17:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:17:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:17:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE2006, КНС_ШинаГлавнаяЗаземляющаяСИзоляторами_DKC:NE2006:994944
In: Этаж 01
Type - Material: DKC_Медь, DKC_Полиэстер
Pset_BuildingElementProxyCommon - Reference: NE2006
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE2006; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE2006/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001470; Описание: Назначение: • заземление и уравнивание потенциалов электроустановок. Характеристики: • метизы (болты, гайки, шайбы) из нержавеющей стали включены в комплект; • материал изоляторов – полиэстер с армированным стекловолокном; Комментарии к типоразмеру: Уравнивание потенциалов Jupiter

# IfcBuildingElementProxy: NE2010, КНС_ШинаГлавнаяЗаземляющаяСИзоляторами_DKC:NE2010:995103
In: Этаж 01
Type - Material: DKC_Медь, DKC_Полиэстер
Pset_BuildingElementProxyCommon - Reference: NE2010
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE2010; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE2010/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001470; Описание: Назначение: • заземление и уравнивание потенциалов электроустановок. Характеристики: • метизы (болты, гайки, шайбы) из нержавеющей стали включены в комплект; • материал изоляторов – полиэстер с армированным стекловолокном; Комментарии к типоразмеру: Уравнивание потенциалов Jupiter

# IfcBuildingElementProxy: NE2020, КНС_ШинаГлавнаяЗаземляющаяСИзоляторами_DKC:NE2020:995112
In: Этаж 01
Type - Material: DKC_Медь, DKC_Полиэстер
Pset_BuildingElementProxyCommon - Reference: NE2020
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE2020; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE2020/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001470; Описание: Назначение: • заземление и уравнивание потенциалов электроустановок. Характеристики: • метизы (болты, гайки, шайбы) из нержавеющей стали включены в комплект; • материал изоляторов – полиэстер с армированным стекловолокном; Комментарии к типоразмеру: Уравнивание потенциалов Jupiter
