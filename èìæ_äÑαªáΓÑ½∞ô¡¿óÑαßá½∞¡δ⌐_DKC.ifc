Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:30:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:30:05 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{1DFE1739-946A-4164-837E-343C6B2E963A}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:30:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:30:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:30:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND1000_Полипропилен, КНС_ДержательУниверсальный_DKC:ND1000_Полипропилен:679073
In: Этаж 01
Type - Material: DKC_Полипропилен
Pset_BuildingElementProxyCommon - Reference: ND1000_Полипропилен
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND1000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: ● крепление молниеприемной сетки на плоской кровле. Характеристики: ● разборная конструкция; ● использование фасадного держателя ND2301 для крепления полосы 40х4 мм; ● возможность крепления с помощью саморезов.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2000_Полипропилен, КНС_ДержательУниверсальный_DKC:ND2000_Полипропилен:679142
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: ND2000_Полипропилен
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: ● крепление молниеприемной сетки и полосы на фасадах и кровле. Характеристики: ● разборная конструкция; ● возможность резьбового крепления; ● возможность крепления одним винтом.; Комментарии к типоразмеру: Держатели Jupiter
