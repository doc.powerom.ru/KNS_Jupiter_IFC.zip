Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:26:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:26:41 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{988AD0F6-54E1-43E9-8047-66A450EBB6D7}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:26:40 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:26:41 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:26:41 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NK3001_Гальванически оцинкованнная сталь_D32, КНС_ХомутТрубныйДляИзоляционнойШтанги_DKC:NK3001_Гальванически оцинкованнная сталь_D32:1016339
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NK3001_Гальванически оцинкованнная сталь_D32
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NK3001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NK3001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление изоляционной штанги на трубу малого диаметра. Характеристики: • соединение штанг друг с другом с помощью хомута NK3001; • крепление штанги к изолированной молниеприемной мачте с помощью держателя NK3002.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NK3002_Гальванически оцинкованнная сталь_D40, КНС_ХомутТрубныйДляИзоляционнойШтанги_DKC:NK3002_Гальванически оцинкованнная сталь_D40:1016595
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NK3002_Гальванически оцинкованнная сталь_D40
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NK3002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NK3002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000509; Описание: Назначение: • крепление изоляционной штанги на трубу малого диаметра. Характеристики: • соединение штанг друг с другом с помощью хомута NK3001; • крепление штанги к изолированной молниеприемной мачте с помощью держателя NK3002.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг
