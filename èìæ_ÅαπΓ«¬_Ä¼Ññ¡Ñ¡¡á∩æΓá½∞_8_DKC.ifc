Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:16:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:16:08 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F0A70FD2-5311-451A-BD60-09C04F4952E3}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:16:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:16:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:16:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; Group: Механизмы Молниезащита_Пруток 3
Name
InPort_612102
2 x OutPort_660566
InPort_612104

# IfcFlowFitting: Стандарт, КНС_Поворот_Пруток_Неспецифицируемое_DKC:Стандарт:660566
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Стандарт
Group: Механизмы Молниезащита_Пруток 3

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Омеднение_8_DKC (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Омеднение_8_DKC
Group: Механизмы Молниезащита_Пруток 3
Name (Воздуховод круглого сечения:КНС_Пруток_Омеднение_8_DKC:...)
612102
612104
