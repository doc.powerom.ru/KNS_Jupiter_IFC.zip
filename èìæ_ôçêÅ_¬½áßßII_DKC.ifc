Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:31:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:31:38 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{457AC44C-57CF-47D7-9652-E9C3552DF605}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:31:37 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:31:37 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:31:37 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NX2011, КНС_УЗИП_классII_DKC:NX2011:1044735
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2011
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NX2011; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2011/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2012, КНС_УЗИП_классII_DKC:NX2012:1044988
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2012
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: комплект; ADSK_Код изделия: NX2012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2013, КНС_УЗИП_классII_DKC:NX2013:1045008
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2013
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2013; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2013/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2021, КНС_УЗИП_классII_DKC:NX2021:1045011
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2021
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2021; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2021/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2022, КНС_УЗИП_классII_DKC:NX2022:1045014
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2022
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2022; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2022/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2031, КНС_УЗИП_классII_DKC:NX2031:1045017
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2031
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2031; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2031/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2032, КНС_УЗИП_классII_DKC:NX2032:1045020
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2032
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2032; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2032/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2041, КНС_УЗИП_классII_DKC:NX2041:1045023
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2041
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2041; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2041/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2042, КНС_УЗИП_классII_DKC:NX2042:1045026
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2042
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2042; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2042/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне распределительного щита. Характеристики: • УЗИП на основе оксидно-цинковых варисторов рекомендуется для защиты сетей низкого напряжения от импульсов перенапряжения, возникающих при коротких замыканиях, коммутации энергоемкого оборудования или удаленном ударе молнии в питающую сеть.; Комментарии к типоразмеру: Jupiter УЗИП класс II
