Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:25:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:25:05 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9F9F5BFB-B23F-42DA-9D84-8C5DC7E7CF03}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:25:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:25:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:25:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL3000HV_Нержавеющая сталь_3м, КНС_МачтаИзолированнаяМолниеприемная_DKC:NL3000HV_Нержавеющая сталь_3м:1009201
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL3000HV_Нержавеющая сталь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL3000HV; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL3000HV/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • прокладка изолированного токоотвода внутри мачты; • прокладка дополнительного изолированного токоотвода снаружи мачты. Характеристики: • со вставками из стеклопластика; • установка на кровлю с помощью треноги NL0700 и бетонных оснований NL0500; • установка на вертикальную поверхность с помощью держателей NL0100; • установка на прямоугольные профили либо трубы с помощью хомутов NK3103/NK3104 и держателей NK3105.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода

# IfcBuildingElementProxy: NL4000HV_Нержавеющая сталь_4м, КНС_МачтаИзолированнаяМолниеприемная_DKC:NL4000HV_Нержавеющая сталь_4м:1009506
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL4000HV_Нержавеющая сталь_4м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL4000HV; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL4000HV/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • прокладка изолированного токоотвода внутри мачты; • прокладка дополнительного изолированного токоотвода снаружи мачты. Характеристики: • со вставками из стеклопластика; • установка на кровлю с помощью треноги NL0700 и бетонных оснований NL0500; • установка на вертикальную поверхность с помощью держателей NL0100; • установка на прямоугольные профили либо трубы с помощью хомутов NK3103/NK3104 и держателей NK3105.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода

# IfcBuildingElementProxy: NL5000HV_Нержавеющая сталь_5м, КНС_МачтаИзолированнаяМолниеприемная_DKC:NL5000HV_Нержавеющая сталь_5м:1009530
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL5000HV_Нержавеющая сталь_5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5000HV; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5000HV/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • прокладка изолированного токоотвода внутри мачты; • прокладка дополнительного изолированного токоотвода снаружи мачты. Характеристики: • со вставками из стеклопластика; • установка на кровлю с помощью треноги NL0700 и бетонных оснований NL0500; • установка на вертикальную поверхность с помощью держателей NL0100; • установка на прямоугольные профили либо трубы с помощью хомутов NK3103/NK3104 и держателей NK3105.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода

# IfcBuildingElementProxy: NL6000HV_Нержавеющая сталь_6м, КНС_МачтаИзолированнаяМолниеприемная_DKC:NL6000HV_Нержавеющая сталь_6м:1009533
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL6000HV_Нержавеющая сталь_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6000HV; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6000HV/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • прокладка изолированного токоотвода внутри мачты; • прокладка дополнительного изолированного токоотвода снаружи мачты. Характеристики: • со вставками из стеклопластика; • установка на кровлю с помощью треноги NL0700 и бетонных оснований NL0500; • установка на вертикальную поверхность с помощью держателей NL0100; • установка на прямоугольные профили либо трубы с помощью хомутов NK3103/NK3104 и держателей NK3105.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода

# IfcBuildingElementProxy: NL7000HV_Нержавеющая сталь_7м, КНС_МачтаИзолированнаяМолниеприемная_DKC:NL7000HV_Нержавеющая сталь_7м:1009536
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL7000HV_Нержавеющая сталь_7м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7000HV; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7000HV/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • прокладка изолированного токоотвода внутри мачты; • прокладка дополнительного изолированного токоотвода снаружи мачты. Характеристики: • со вставками из стеклопластика; • установка на кровлю с помощью треноги NL0700 и бетонных оснований NL0500; • установка на вертикальную поверхность с помощью держателей NL0100; • установка на прямоугольные профили либо трубы с помощью хомутов NK3103/NK3104 и держателей NK3105.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода
