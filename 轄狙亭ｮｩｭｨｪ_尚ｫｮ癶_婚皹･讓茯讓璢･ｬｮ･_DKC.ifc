Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:03:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:03:21 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{0A69A42F-5009-4F6C-A5A2-BBAF150E08C2}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:03:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:03:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:03:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3105CU_Медь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105CU_Медь_80х70 мм:621776
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3105CU_Медь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:621706
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106CU_Медь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106CU_Медь_100х100 мм:621927
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3106CU_Медь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:621831
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_619029 | Механизмы Молниезащита_Полоса 14
2 x OutPort_621704 | Механизмы Молниезащита_Полоса 14
InPort_619030 | Механизмы Молниезащита_Полоса 14
InPort_619387 | Механизмы Молниезащита_Полоса 9
2 x OutPort_621774 | Механизмы Молниезащита_Полоса 9
InPort_619390 | Механизмы Молниезащита_Полоса 9
InPort_619404 | Механизмы Молниезащита_Полоса 10
2 x OutPort_621829 | Механизмы Молниезащита_Полоса 10
InPort_619407 | Механизмы Молниезащита_Полоса 10
InPort_619421 | Механизмы Молниезащита_Полоса 11
2 x OutPort_621925 | Механизмы Молниезащита_Полоса 11
InPort_619424 | Механизмы Молниезащита_Полоса 11
InPort_621704 | Механизмы Молниезащита_Полоса 14
OutPort_621705 | Механизмы Молниезащита_Полоса 14
InPort_621774 | Механизмы Молниезащита_Полоса 9
OutPort_621775 | Механизмы Молниезащита_Полоса 9
InPort_621829 | Механизмы Молниезащита_Полоса 10
OutPort_621830 | Механизмы Молниезащита_Полоса 10
InPort_621925 | Механизмы Молниезащита_Полоса 11
OutPort_621926 | Механизмы Молниезащита_Полоса 11

# IfcFlowFitting: NG3105CU_Медь_80х70 мм, КНС_Тройник_Полоса_Неспецифицируемое_DKC:NG3105CU_Медь_80х70 мм:621774
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105CU_Медь_80х70 мм
Group: Механизмы Молниезащита_Полоса 9

# IfcFlowFitting: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_Тройник_Полоса_Неспецифицируемое_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:621704
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Group: Механизмы Молниезащита_Полоса 14

# IfcFlowFitting: NG3106CU_Медь_100х100 мм, КНС_Тройник_Полоса_Неспецифицируемое_DKC:NG3106CU_Медь_100х100 мм:621925
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106CU_Медь_100х100 мм
Group: Механизмы Молниезащита_Полоса 11

# IfcFlowFitting: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_Тройник_Полоса_Неспецифицируемое_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:621829
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Group: Механизмы Молниезащита_Полоса 10

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC (12)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC:...) | Group
619029 | Механизмы Молниезащита_Полоса 14
619030 | Механизмы Молниезащита_Полоса 14
619387 | Механизмы Молниезащита_Полоса 9
619390 | Механизмы Молниезащита_Полоса 9
619404 | Механизмы Молниезащита_Полоса 10
619407 | Механизмы Молниезащита_Полоса 10
619421 | Механизмы Молниезащита_Полоса 11
619424 | Механизмы Молниезащита_Полоса 11
621705 | Механизмы Молниезащита_Полоса 14
621775 | Механизмы Молниезащита_Полоса 9
621830 | Механизмы Молниезащита_Полоса 10
621926 | Механизмы Молниезащита_Полоса 11
