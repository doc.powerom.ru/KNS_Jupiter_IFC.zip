Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:10:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:10:30 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{1A3458E1-CCDF-4FD3-8672-96EF8D1A54BD}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:10:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:10:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:10:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2212CU_Медь_450 мм, КНС_ДержательПластиковыйПодЧерепицу_DKC:ND2212CU_Медь_450 мм:963065
In: Этаж 01
Type - Material: DKC_Пластик_Красный, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2212CU_Медь_450 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2212CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2212CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2212_Горячеоцинкованная сталь_450 мм, КНС_ДержательПластиковыйПодЧерепицу_DKC:ND2212_Горячеоцинкованная сталь_450 мм:963058
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2212_Горячеоцинкованная сталь_450 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2212; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2212/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2213CU_Медь_415 мм, КНС_ДержательПластиковыйПодЧерепицу_DKC:ND2213CU_Медь_415 мм:964344
In: Этаж 01
Type - Material: DKC_Пластик_Красный, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2213CU_Медь_415 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2213CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2213CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2213_Горячеоцинкованная сталь_415 мм, КНС_ДержательПластиковыйПодЧерепицу_DKC:ND2213_Горячеоцинкованная сталь_415 мм:963066
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2213_Горячеоцинкованная сталь_415 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2213; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2213/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2214_Горячеоцинкованная сталь_330 мм, КНС_ДержательПластиковыйПодЧерепицу_DKC:ND2214_Горячеоцинкованная сталь_330 мм:964345
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2214_Горячеоцинкованная сталь_330 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2214; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2214/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter
