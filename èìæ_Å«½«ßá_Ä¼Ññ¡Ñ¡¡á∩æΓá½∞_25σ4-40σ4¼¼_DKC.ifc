Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:26:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:26:20 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{48B9C16B-4366-4353-8D6E-A29CA1A04372}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:26:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:26:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:26:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_615846 | Механизмы Молниезащита_Полоса 30
2 x OutPort_615848 | Механизмы Молниезащита_Полоса 30
InPort_615847 | Механизмы Молниезащита_Полоса 30
InPort_615849 | Механизмы Молниезащита_Полоса 32
2 x OutPort_615851 | Механизмы Молниезащита_Полоса 32
InPort_615850 | Механизмы Молниезащита_Полоса 32

# IfcFlowFitting: Изгиб полосы (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Изгиб полосы
Name (КНС_Поворот_Полоса_Неспецифицируемое_DKC:Изгиб полосы:...) | Group
615848 | Механизмы Молниезащита_Полоса 30
615851 | Механизмы Молниезащита_Полоса 32

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Омеднение_25х4/40х4мм_DKC (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Омеднение_25х4/40х4мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Омеднение_25х4/40х4мм_DKC:...) | Group
615846 | Механизмы Молниезащита_Полоса 30
615847 | Механизмы Молниезащита_Полоса 30
615849 | Механизмы Молниезащита_Полоса 32
615850 | Механизмы Молниезащита_Полоса 32
