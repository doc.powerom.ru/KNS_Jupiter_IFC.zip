Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:08:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:08:58 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F0494FF8-11D2-40D2-B0F8-3A8F1AC779C6}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:08:57 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:08:57 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:08:57 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2206CU_Медь_330 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2206CU_Медь_330 мм:962579
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2206CU_Медь_330 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2206CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2206CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2206_Сталь горячеоцинкованная_330 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2206_Сталь горячеоцинкованная_330 мм:962572
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2206_Сталь горячеоцинкованная_330 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2206; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2206/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2207CU_Медь_415 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2207CU_Медь_415 мм:962581
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2207CU_Медь_415 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2207CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2207CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2207_Сталь горячеоцинкованная_415 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2207_Сталь горячеоцинкованная_415 мм:962580
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2207_Сталь горячеоцинкованная_415 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2207; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2207/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2208CU_Медь_450 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2208CU_Медь_450 мм:962585
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2208CU_Медь_450 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2208CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2208CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2208_Сталь горячеоцинкованная_450 мм, КНС_ДержательСкрученныйПодЧерепицу_DKC:ND2208_Сталь горячеоцинкованная_450 мм:962584
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2208_Сталь горячеоцинкованная_450 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2208; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2208/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на черепичных и шиферных кровлях. Характеристики: • различная длина основания; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter
