Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:07:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:07:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{56DD6E58-4BE1-447F-BE9E-184CB06EAB39}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:07:55 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:07:55 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:07:55 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL0345_Бетон_20кг, КНС_ОсновниеБетонное_DKC:NL0345_Бетон_20кг:682020
In: Этаж 01
Type - Material: DKC_Бетон
Pset_BuildingElementProxyCommon - Reference: NL0345_Бетон_20кг
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL0345; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL0345/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Описание: Назначение • установка стержневых молниеприемников на плоских горизонтальных поверхностях. Особенности • содержит две точки подключения с резьбой М16 для ввинчивания молниеприемного стержня и специального соединителя; • точки подключения соединены металлической пластиной внутри основания; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL0500_Бетон_40кг, КНС_ОсновниеБетонное_DKC:NL0500_Бетон_40кг:682184
In: Этаж 01
Type - Material: DKC_Бетон
Pset_BuildingElementProxyCommon - Reference: NL0500_Бетон_40кг
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL0500; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL0500/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Описание: Назначение • установка стержневых молниеприемников на плоских горизонтальных поверхностях. Особенности • содержит две точки подключения с резьбой М16 для ввинчивания молниеприемного стержня и специального соединителя; • точки подключения соединены металлической пластиной внутри основания; Комментарии к типоразмеру: Молниеприемники Jupiter
