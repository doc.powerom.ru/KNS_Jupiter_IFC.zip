Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T18:59:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 18:59:55 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{2AE64289-C07B-41DF-8FE5-2BA6D37574AA}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 18:59:55 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 18:59:55 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 18:59:55 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3103CU_Медь, КНС_УниверсальныйСоединитель_DKC:NG3103CU_Медь:762625
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3103CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3103_Горячеоцинкованная сталь, КНС_УниверсальныйСоединитель_DKC:NG3103_Горячеоцинкованная сталь:762526
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3103_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3108CC_Омедненная сталь, КНС_ПараллельныйЗажим_DKC:NG3108CC_Омедненная сталь:762659
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Омедненная
Pset_BuildingElementProxyCommon - Reference: NG3108CC_Омедненная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3108CC; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3108CC/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное соединение прутка с прутком; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3108_Горячеоцинкованная сталь, КНС_ПараллельныйЗажим_DKC:NG3108_Горячеоцинкованная сталь:762647
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3108_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3108; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3108/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное соединение прутка с прутком; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: Горячеоцинкованная сталь, КНС_СоединительКруглогоПроводника_DKC:Горячеоцинкованная сталь:762671
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3202; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • усиленное соединение круглых проводников. Применяется при монтаже термокомпенсационных соединений.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: Омедненная сталь, КНС_СоединительКруглогоПроводника_DKC:Омедненная сталь:762683
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Омедненная
Pset_BuildingElementProxyCommon - Reference: Омедненная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3202CC; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • усиленное соединение круглых проводников. Применяется при монтаже термокомпенсационных соединений.; Комментарии к типоразмеру: Соединители Jupiter

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC (12)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Горячеоцинкованный_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC:...)
762266
762521
762619
762621
762641
762643
762653
762655
762665
762667
762677
762679
