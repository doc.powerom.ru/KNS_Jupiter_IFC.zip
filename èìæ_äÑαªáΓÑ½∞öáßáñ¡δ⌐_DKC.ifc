Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:37:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:37:44 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9671B6DA-1666-4BDD-8494-20DDD34920BD}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:37:44 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:37:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:37:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2301_Горячеоцинкованная сталь_160 мм, КНС_ДержательФасадный_DKC:ND2301_Горячеоцинкованная сталь_160 мм:965802
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Краска_Белый
Pset_BuildingElementProxyCommon - Reference: ND2301_Горячеоцинкованная сталь_160 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2302_Горячеоцинкованная сталь_400 мм, КНС_ДержательФасадный_DKC:ND2302_Горячеоцинкованная сталь_400 мм:965810
In: Этаж 01
Type - Material: DKC_Краска_Белый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2302_Горячеоцинкованная сталь_400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2302; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2302/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2304_Горячеоцинкованная сталь_250 мм, КНС_ДержательФасадный_DKC:ND2304_Горячеоцинкованная сталь_250 мм:965811
In: Этаж 01
Type - Material: DKC_Краска_Белый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2304_Горячеоцинкованная сталь_250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2304; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2304/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2305_Горячеоцинкованная сталь_160 мм, КНС_ДержательФасадный_DKC:ND2305_Горячеоцинкованная сталь_160 мм:965814
In: Этаж 01
Type - Material: DKC_Краска_Белый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2305_Горячеоцинкованная сталь_160 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2305; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2305/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2306_Горячеоцинкованная сталь_125 мм, КНС_ДержательФасадный_DKC:ND2306_Горячеоцинкованная сталь_125 мм:966284
In: Этаж 01
Type - Material: DKC_Краска_Белый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2306_Горячеоцинкованная сталь_125 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2306; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2306/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2307_Горячеоцинкованная сталь_100 мм, КНС_ДержательФасадный_DKC:ND2307_Горячеоцинкованная сталь_100 мм:966288
In: Этаж 01
Type - Material: DKC_Краска_Белый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2307_Горячеоцинкованная сталь_100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2307; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2307/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов (опусков) по фасаду здания. Характеристики: • крепление круглого и плоского проводника; • болтовое крепление проводника; • возможно крепление полосы 40х4 мм в держатель ND2301.; Комментарии к типоразмеру: Держатели Jupiter
