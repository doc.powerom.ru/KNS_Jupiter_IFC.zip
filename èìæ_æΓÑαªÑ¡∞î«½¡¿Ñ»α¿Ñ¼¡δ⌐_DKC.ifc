Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:09:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:09:15 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AC5E889F-F29C-4700-A403-FFCCC8917FD6}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:09:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:09:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:09:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL1000_Алюминий_1м, КНС_СтерженьМолниеприемный_DKC:NL1000_Алюминий_1м:691691
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: NL1000_Алюминий_1м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL1000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж отдельностоящих стержневых молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL2000_Алюминий_2м, КНС_СтерженьМолниеприемный_DKC:NL2000_Алюминий_2м:691841
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: NL2000_Алюминий_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL2000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL2000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж отдельностоящих стержневых молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL3000_Алюминий_3м, КНС_СтерженьМолниеприемный_DKC:NL3000_Алюминий_3м:691879
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: NL3000_Алюминий_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL3000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL3000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж отдельностоящих стержневых молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL4000_Алюминий_4м, КНС_СтерженьМолниеприемный_DKC:NL4000_Алюминий_4м:691887
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: NL4000_Алюминий_4м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL4000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL4000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж отдельностоящих стержневых молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter
