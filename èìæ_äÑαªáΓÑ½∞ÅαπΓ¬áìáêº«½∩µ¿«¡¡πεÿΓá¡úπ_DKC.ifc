Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:25:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:25:25 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{495BB6A5-6EFC-4B31-8F53-8D3BB3590DF2}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:25:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:25:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:25:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NF0001_Гальванически оцинкованнная сталь, КНС_ДержательПруткаНаИзоляционнуюШтангу_DKC:NF0001_Гальванически оцинкованнная сталь:1010666
In: Этаж 01
Type - Material: DKC_Сталь_Гальванически оцинкованнная
Pset_BuildingElementProxyCommon - Reference: NF0001_Гальванически оцинкованнная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NF0001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF0001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление прутка на изоляционной штанге. Характеристики: • держатель крепится на штангу путем простого ввинчивания; • болтовое крепление проводника.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг
