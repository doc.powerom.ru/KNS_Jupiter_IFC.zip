Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:03:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:03:51 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9619DB30-5BE5-4231-9495-B75DA25A8109}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:03:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:03:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:03:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3105CU_Медь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105CU_Медь_80х70 мм:624350
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3105CU_Медь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:624330
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106CU_Медь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106CU_Медь_100х100 мм:624388
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3106CU_Медь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:624369
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_622044 | Механизмы Молниезащита_Полоса 2
4 x OutPort_624329 | Механизмы Молниезащита_Полоса 2
InPort_624263 | Механизмы Молниезащита_Полоса 2
InPort_624327 | Механизмы Молниезащита_Полоса 2
InPort_624328 | Механизмы Молниезащита_Полоса 2
InPort_624345 | Механизмы Молниезащита_Полоса 3
4 x OutPort_624349 | Механизмы Молниезащита_Полоса 3
InPort_624346 | Механизмы Молниезащита_Полоса 3
InPort_624347 | Механизмы Молниезащита_Полоса 3
InPort_624348 | Механизмы Молниезащита_Полоса 3
InPort_624364 | Механизмы Молниезащита_Полоса 4
4 x OutPort_624368 | Механизмы Молниезащита_Полоса 4
InPort_624365 | Механизмы Молниезащита_Полоса 4
InPort_624366 | Механизмы Молниезащита_Полоса 4
InPort_624367 | Механизмы Молниезащита_Полоса 4
InPort_624383 | Механизмы Молниезащита_Полоса 8
4 x OutPort_624387 | Механизмы Молниезащита_Полоса 8
InPort_624384 | Механизмы Молниезащита_Полоса 8
InPort_624385 | Механизмы Молниезащита_Полоса 8
InPort_624386 | Механизмы Молниезащита_Полоса 8

# IfcFlowFitting: NG3105CU_Медь_80х70 мм, КНС_Крестовина_Полоса_Неспецифицируемое_DKC:NG3105CU_Медь_80х70 мм:624349
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105CU_Медь_80х70 мм
Group: Механизмы Молниезащита_Полоса 3

# IfcFlowFitting: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_Крестовина_Полоса_Неспецифицируемое_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:624329
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Group: Механизмы Молниезащита_Полоса 2

# IfcFlowFitting: NG3106CU_Медь_100х100 мм, КНС_Крестовина_Полоса_Неспецифицируемое_DKC:NG3106CU_Медь_100х100 мм:624387
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106CU_Медь_100х100 мм
Group: Механизмы Молниезащита_Полоса 8

# IfcFlowFitting: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_Крестовина_Полоса_Неспецифицируемое_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:624368
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Group: Механизмы Молниезащита_Полоса 4

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC (16)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC:...) | Group
622044 | Механизмы Молниезащита_Полоса 2
624263 | Механизмы Молниезащита_Полоса 2
624327 | Механизмы Молниезащита_Полоса 2
624328 | Механизмы Молниезащита_Полоса 2
624345 | Механизмы Молниезащита_Полоса 3
624346 | Механизмы Молниезащита_Полоса 3
624347 | Механизмы Молниезащита_Полоса 3
624348 | Механизмы Молниезащита_Полоса 3
624364 | Механизмы Молниезащита_Полоса 4
624365 | Механизмы Молниезащита_Полоса 4
624366 | Механизмы Молниезащита_Полоса 4
624367 | Механизмы Молниезащита_Полоса 4
624383 | Механизмы Молниезащита_Полоса 8
624384 | Механизмы Молниезащита_Полоса 8
624385 | Механизмы Молниезащита_Полоса 8
624386 | Механизмы Молниезащита_Полоса 8
