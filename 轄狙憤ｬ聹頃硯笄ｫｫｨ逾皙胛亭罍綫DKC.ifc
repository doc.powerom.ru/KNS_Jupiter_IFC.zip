Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:40:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:40:06 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B4E01440-88BB-4999-A1BD-7C5F71668C17}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:40:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:40:06 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:40:06 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3001CU_Медь_D80-160, КНС_ХомутНаМеталлическуюТрубу_DKC:NG3001CU_Медь_D80-160:971256
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3001CU_Медь_D80-160
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3001CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3001CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов к водосточным трубам. Характеристики: • регулируемый диапазон для труб различного диаметра; • болтовое крепление проводника.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: NG3001_Нержавеющая сталь_D80-160, КНС_ХомутНаМеталлическуюТрубу_DKC:NG3001_Нержавеющая сталь_D80-160:971249
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NG3001_Нержавеющая сталь_D80-160
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов к водосточным трубам. Характеристики: • регулируемый диапазон для труб различного диаметра; • болтовое крепление проводника.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: NG3002CU_Медь_D20-80, КНС_ХомутНаМеталлическуюТрубу_DKC:NG3002CU_Медь_D20-80:971258
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3002CU_Медь_D20-80
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3002CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3002CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов к водосточным трубам. Характеристики: • регулируемый диапазон для труб различного диаметра; • болтовое крепление проводника.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: NG3002_Нержавеющая сталь_D20-80, КНС_ХомутНаМеталлическуюТрубу_DKC:NG3002_Нержавеющая сталь_D20-80:971257
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NG3002_Нержавеющая сталь_D20-80
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление токоотводов к водосточным трубам. Характеристики: • регулируемый диапазон для труб различного диаметра; • болтовое крепление проводника.; Комментарии к типоразмеру: Держатели Jupiter
