Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:27:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:27:12 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9F6DC470-95D5-4433-8711-3E0FEA5E1999}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:27:11 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:27:11 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:27:11 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (12)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_616019 | Механизмы Молниезащита_Полоса 31
2 x OutPort_616021 | Механизмы Молниезащита_Полоса 31
InPort_616020 | Механизмы Молниезащита_Полоса 31
InPort_616022 | Механизмы Молниезащита_Полоса 34
2 x OutPort_616024 | Механизмы Молниезащита_Полоса 34
InPort_616023 | Механизмы Молниезащита_Полоса 34
InPort_616025 | Механизмы Молниезащита_Полоса 36
2 x OutPort_616027 | Механизмы Молниезащита_Полоса 36
InPort_616026 | Механизмы Молниезащита_Полоса 36

# IfcFlowFitting: Изгиб полосы (3)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Изгиб полосы
Name (КНС_Поворот_Полоса_Неспецифицируемое_DKC:Изгиб полосы:...) | Group
616021 | Механизмы Молниезащита_Полоса 31
616024 | Механизмы Молниезащита_Полоса 34
616027 | Механизмы Молниезащита_Полоса 36

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Медь_20х4/25х4/40х4мм_DKC (6)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Медь_20х4/25х4/40х4мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Медь_20х4/25х4/40х4мм_DKC:...) | Group
616019 | Механизмы Молниезащита_Полоса 31
616020 | Механизмы Молниезащита_Полоса 31
616022 | Механизмы Молниезащита_Полоса 34
616023 | Механизмы Молниезащита_Полоса 34
616025 | Механизмы Молниезащита_Полоса 36
616026 | Механизмы Молниезащита_Полоса 36
