Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:27:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:27:48 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{71E4288C-48C2-4265-801D-F999EA0B4DC1}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:27:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:27:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:27:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG6607_Алюминий, КНС_СоединительESEМолниеприемникМачта_DKC:NG6607_Алюминий:1020030
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NG6607_Алюминий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG6607; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6607/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: ● подключение ESE молниеприемника к мачтам 5–6 метров. Характеристики: ● ввинчивается в основание ESE молниеприемника и крепится к мачтам 5–6 метров.; Комментарии к типоразмеру: Jupiter Элементы для монтажа
