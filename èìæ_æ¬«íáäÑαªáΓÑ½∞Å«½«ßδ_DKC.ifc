Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:38:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:38:52 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{17EEFCA7-4277-4F97-BA2A-A45FDE41F19D}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:38:52 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:38:52 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:38:52 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2310_Горячеоцинкованная сталь_70 мм, КНС_СкобаДержательПолосы_DKC:ND2310_Горячеоцинкованная сталь_70 мм:968868
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2310_Горячеоцинкованная сталь_70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2310; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2310/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление проводника-полосы к фасаду и внутренним стенам. Характеристики: • подготовленные отверстия в основании для крепления к поверхностям; • толщина фиксируемой полосы – до 6 мм.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2311CU_Медь_45 мм, КНС_СкобаДержательПолосы_DKC:ND2311CU_Медь_45 мм:968876
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2311CU_Медь_45 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2311CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2311CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление проводника-полосы к фасаду и внутренним стенам. Характеристики: • подготовленные отверстия в основании для крепления к поверхностям; • толщина фиксируемой полосы – до 6 мм.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2311_Горячеоцинкованная сталь_45 мм, КНС_СкобаДержательПолосы_DKC:ND2311_Горячеоцинкованная сталь_45 мм:968875
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2311_Горячеоцинкованная сталь_45 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2311; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2311/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000508; Описание: Назначение: • крепление проводника-полосы к фасаду и внутренним стенам. Характеристики: • подготовленные отверстия в основании для крепления к поверхностям; • толщина фиксируемой полосы – до 6 мм.; Комментарии к типоразмеру: Держатели Jupiter
