Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:14:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:14:16 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DA3C68BF-D82A-49D8-A6BC-05E52683D243}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:14:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:14:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:14:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE1105_Горячеоцинкованная сталь_2м, КНС_ЗаземлительВертикальныйПрофильный_DKC:NE1105_Горячеоцинкованная сталь_2м:985721
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NE1105_Горячеоцинкованная сталь_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000492; Описание: Назначение: • вертикальный заземлитель. Характеристики: • в комплекте имеется крепежный материал для болтового подключения к горизонтальному контуру заземления.; Комментарии к типоразмеру: Заземление "Jupiter"

# IfcBuildingElementProxy: NE5503_Горячеоцинкованная сталь_3м, КНС_ЗаземлительВертикальныйПрофильный_DKC:NE5503_Горячеоцинкованная сталь_3м:986010
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NE5503_Горячеоцинкованная сталь_3м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE5503; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE5503/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000492; Описание: Назначение: • вертикальный заземлитель. Характеристики: • в комплекте имеется крепежный материал для болтового подключения к горизонтальному контуру заземления.; Комментарии к типоразмеру: Заземление "Jupiter"
