Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:01:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:01:21 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{85A404CD-E339-445D-BC1A-CF5648D9B670}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:01:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:01:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:01:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3107CU_Медь, КНС_ПараллельныйЗажим_DKC:NG3107CU_Медь:830929
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3107CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3107CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3107CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное соединение прутка с прутком; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3107_Горячеоцинкованная сталь, КНС_ПараллельныйЗажим_DKC:NG3107_Горячеоцинкованная сталь:830488
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3107_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3107; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3107/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное соединение прутка с прутком; Комментарии к типоразмеру: Соединители Jupiter

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC (6)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Горячеоцинкованный_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC:...)
830552
830595
830624
830931
830933
830935

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Медь_8/10мм_DKC (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Медь_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Медь_8/10мм_DKC:...)
828894
830926
