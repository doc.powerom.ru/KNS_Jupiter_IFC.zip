Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:13:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:13:32 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9AD89364-073F-4727-8FC3-69199F671F0E}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:13:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:13:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:13:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE1003_Нержавеющая сталь_М10, КНС_ТочкаЗаземления_DKC:NE1003_Нержавеющая сталь_М10:977482
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NE1003_Нержавеющая сталь_М10
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001479; Описание: Назначение: • используется в качестве точки подключения токоотводов к арматуре здания/прохода через стены. Характеристики: • крепление к арматуре с помощью зажима ND2004.; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1004_Нержавеющая сталь_М12, КНС_ТочкаЗаземления_DKC:NE1004_Нержавеющая сталь_М12:977622
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NE1004_Нержавеющая сталь_М12
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1004; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1004/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001479; Описание: Назначение: • используется в качестве точки подключения токоотводов к арматуре здания/прохода через стены. Характеристики: • крепление к арматуре с помощью зажима ND2004.; Комментарии к типоразмеру: Заземление Jupiter
