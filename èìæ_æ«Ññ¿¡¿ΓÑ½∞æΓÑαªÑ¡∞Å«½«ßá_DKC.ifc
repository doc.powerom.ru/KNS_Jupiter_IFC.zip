Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:16:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:16:06 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{628BFF96-E0AF-489C-872C-7EB8C21641C5}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:16:06 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:16:06 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:16:06 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3116INOX_Нержавеющая сталь_80х70 мм, КНС_СоединительСтерженьПолоса_DKC:NG3116INOX_Нержавеющая сталь_80х70 мм:991870
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NG3116INOX_Нержавеющая сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3116INOX; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3116INOX/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001465; Описание: Назначение: • подключение вертикального стержневого заземлителя к полосе 40х4 или 25х4 мм. Характеристики: • подходит как для заземлителя с муфтовым соединением, так и для заземлителя на основе безмуфтового крепления.; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NG3116_Горячеоцинкованная сталь_80х70 мм, КНС_СоединительСтерженьПолоса_DKC:NG3116_Горячеоцинкованная сталь_80х70 мм:991620
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3116_Горячеоцинкованная сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3116; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3116/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001465; Описание: Назначение: • подключение вертикального стержневого заземлителя к полосе 40х4 или 25х4 мм. Характеристики: • подходит как для заземлителя с муфтовым соединением, так и для заземлителя на основе безмуфтового крепления.; Комментарии к типоразмеру: Заземление Jupiter
