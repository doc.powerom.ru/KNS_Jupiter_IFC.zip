Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:07:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:07:17 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9181EF4A-D8A1-428C-BCF8-5CAD74A91B24}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:07:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:07:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:07:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2203CU_Медь_Увеличенный, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2203CU_Медь_Увеличенный:960056
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2203CU_Медь_Увеличенный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2203CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2203CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2203_Горячеоцинкованная сталь_Увеличенный, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2203_Горячеоцинкованная сталь_Увеличенный:960049
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2203_Горячеоцинкованная сталь_Увеличенный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2203; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2203/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2204CU_Медь_Пластиковый держатель, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2204CU_Медь_Пластиковый держатель:960058
In: Этаж 01
Type - Material: DKC_Пластик_Красный, DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2204CU_Медь_Пластиковый держатель
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2204CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2204CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2204_Горячеоцинкованная сталь_Пластиковый держатель, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2204_Горячеоцинкованная сталь_Пластиковый держатель:960057
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2204_Горячеоцинкованная сталь_Пластиковый держатель
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2204; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2204/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник крепится простым защелкиванием.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2205CU_Медь, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2205CU_Медь:960091
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2205CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2205CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2205CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2205_Горячеоцинкованная сталь, КНС_ЗажимКоньковыйРегулируемый_DKC:ND2205_Горячеоцинкованная сталь:960090
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2205_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2205; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2205/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на коньке кровли. Характеристики: • регулируемый диапазон зажима; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter
