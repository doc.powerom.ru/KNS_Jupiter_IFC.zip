Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:12:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:12:28 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4382B251-D20D-43A9-B123-10188E389BF2}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:12:28 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:12:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:12:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NL6100_Алюминий_1м, КНС_МолниеприемникКоньковыйСУгловымЗажимом_DKC:NL6100_Алюминий_1м:973391
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: NL6100_Алюминий_1м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6100; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на острый конек кровли. Характеристики: • основание с отверстиями для крепления держателя саморезами; • в комплекте имеется установочный соединитель для подключения токоотвода.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6150_Алюминий_1.5м, КНС_МолниеприемникКоньковыйСУгловымЗажимом_DKC:NL6150_Алюминий_1.5м:973396
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый, DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: NL6150_Алюминий_1.5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6150; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6150/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на острый конек кровли. Характеристики: • основание с отверстиями для крепления держателя саморезами; • в комплекте имеется установочный соединитель для подключения токоотвода.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6200_Алюминий_2м, КНС_МолниеприемникКоньковыйСУгловымЗажимом_DKC:NL6200_Алюминий_2м:973397
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная, DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NL6200_Алюминий_2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6200; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6200/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • установка на острый конек кровли. Характеристики: • основание с отверстиями для крепления держателя саморезами; • в комплекте имеется установочный соединитель для подключения токоотвода.; Комментарии к типоразмеру: Молниеприемники Jupiter
