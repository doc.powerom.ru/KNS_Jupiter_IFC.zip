Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T14:32:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 14:32:19 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9813382F-5D5D-4176-A021-A03BC78F42C9}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 14:32:19 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 14:32:19 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 14:32:19 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2001CU_Медь, КНС_ЗажимФальцевый_DKC:ND2001CU_Медь:954126
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2001CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2001CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2001CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • соединение катанки с металлическими конструкциями или фальцем кровли. Характеристики: • надежное болтовое крепление к металлическим конструкциям; • поворачивающиеся пластины позволяют закрепить пруток под произвольным углом.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2001_Горячеоцинкованная сталь, КНС_ЗажимФальцевый_DKC:ND2001_Горячеоцинкованная сталь:954018
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2001_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • соединение катанки с металлическими конструкциями или фальцем кровли. Характеристики: • надежное болтовое крепление к металлическим конструкциям; • поворачивающиеся пластины позволяют закрепить пруток под произвольным углом.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2002CU_Медь, КНС_ЗажимФальцевый_DKC:ND2002CU_Медь:954142
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2002CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2002CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2002CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • соединение катанки с металлическими конструкциями или фальцем кровли. Характеристики: • надежное болтовое крепление к металлическим конструкциям; • поворачивающиеся пластины позволяют закрепить пруток под произвольным углом.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2002_Горячеоцинкованная сталь, КНС_ЗажимФальцевый_DKC:ND2002_Горячеоцинкованная сталь:954134
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2002_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000513; Описание: Назначение: • соединение катанки с металлическими конструкциями или фальцем кровли. Характеристики: • надежное болтовое крепление к металлическим конструкциям; • поворачивающиеся пластины позволяют закрепить пруток под произвольным углом.; Комментарии к типоразмеру: Держатели Jupiter
