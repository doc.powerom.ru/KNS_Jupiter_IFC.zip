Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:15:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:15:49 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{871E43E6-335C-46B7-947E-F9EEF508EA11}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:15:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:15:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:15:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NE1402_Латунь_D16, КНС_НаконечникВертикальногоЗаземлителя_DKC:NE1402_Латунь_D16:990471
In: Этаж 01
Type - Material: DKC_Латунь
Pset_BuildingElementProxyCommon - Reference: NE1402_Латунь_D16
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1402; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1402/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001628; Описание: Назначение: • для упрощения забивания вертикального стержневого заземлителя.; Комментарии к типоразмеру: Заземление Jupiter

# IfcBuildingElementProxy: NE1407_Сталь_D14, КНС_НаконечникВертикальногоЗаземлителя_DKC:NE1407_Сталь_D14:990627
In: Этаж 01
Type - Material: DKC_Сталь
Pset_BuildingElementProxyCommon - Reference: NE1407_Сталь_D14
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NE1407; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NE1407/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000490; Описание: Назначение: • для упрощения забивания вертикального стержневого заземлителя.; Комментарии к типоразмеру: Заземление Jupiter
