Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:31:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:31:19 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{BB0A0032-80F5-4ACC-9D83-5A48D3120543}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:31:18 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:31:19 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:31:19 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NX2000, КНС_СменныйМодульУЗИП_классII_DKC:NX2000:1039789
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2000
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • сменный элемент дает возможность сохранить устройство защиты от перенапряжений в рабочем состоянии в случае выхода из строя одного из УЗИП класса II.; Комментарии к типоразмеру: Jupiter УЗИП класс II

# IfcBuildingElementProxy: NX2001, КНС_СменныйМодульУЗИП_классII_DKC:NX2001:1039898
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX2001
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX2001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX2001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • сменный элемент дает возможность сохранить устройство защиты от перенапряжений в рабочем состоянии в случае выхода из строя одного из УЗИП класса II.; Комментарии к типоразмеру: Jupiter УЗИП класс II
