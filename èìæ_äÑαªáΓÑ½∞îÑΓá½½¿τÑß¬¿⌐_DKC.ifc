Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T15:04:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 15:04:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{7A623FED-F316-43B5-999B-F0BD40624463}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 15:04:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 15:04:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 15:04:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ND2105CU_Медь_150 мм, КНС_ДержательМеталлический_DKC:ND2105CU_Медь_150 мм:957688
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2105CU_Медь_150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2105CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2105CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на кровле при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2105_Горячеоцинкованная сталь_150 мм, КНС_ДержательМеталлический_DKC:ND2105_Горячеоцинкованная сталь_150 мм:957356
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2105_Горячеоцинкованная сталь_150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на кровле при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2106CU_Медь_100 мм, КНС_ДержательМеталлический_DKC:ND2106CU_Медь_100 мм:957704
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: ND2106CU_Медь_100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2106CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2106CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на кровле при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter

# IfcBuildingElementProxy: ND2106_Горячеоцинкованная сталь_100 мм, КНС_ДержательМеталлический_DKC:ND2106_Горячеоцинкованная сталь_100 мм:957696
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: ND2106_Горячеоцинкованная сталь_100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: ND2106; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/ND2106/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000507; Описание: Назначение: • крепление молниеприемной сетки на кровле при помощи саморезов. Характеристики: • основание с отверстиями для крепления держателя саморезами; • проводник закрепляется безвинтовым зажимом при помощи плоскогубцев.; Комментарии к типоразмеру: Держатели Jupiter
