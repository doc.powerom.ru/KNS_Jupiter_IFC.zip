Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:30:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:30:02 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{2B8A777B-7575-4798-8D67-88DA9EFB9A22}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:30:02 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:30:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:30:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NX1001, КНС_УЗИП_классI_DKC:NX1001:1021934
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1001
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1001/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000381; Описание: Назначение: • установка на уровне ввода в здание кабельных и воздушных линий. Характеристики: • УЗИП на основе газонаполненных разрядников рекомендуется к применению в зданиях, обладающих внешней системой молниезащиты или снабжающихся электроэнергией по воздушным линиям.; Комментарии к типоразмеру: Jupiter УЗИП класс I

# IfcBuildingElementProxy: NX1012, КНС_УЗИП_классI_DKC:NX1012:1022065
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1012
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000381; Описание: Назначение: • установка на уровне ввода в здание кабельных и воздушных линий. Характеристики: • УЗИП на основе газонаполненных разрядников рекомендуется к применению в зданиях, обладающих внешней системой молниезащиты или снабжающихся электроэнергией по воздушным линиям.; Комментарии к типоразмеру: Jupiter УЗИП класс I
