Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:26:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:26:05 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{5EC58984-2ABF-44A9-A851-C1D0C4BCD8C0}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:26:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:26:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:26:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NF0500_Стеклопластик_500 мм, КНС_ШтангаИзоляционная_DKC:NF0500_Стеклопластик_500 мм:1013661
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF0500_Стеклопластик_500 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF0500; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF0500/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NF0750_Стеклопластик_750 мм, КНС_ШтангаИзоляционная_DKC:NF0750_Стеклопластик_750 мм:1014188
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF0750_Стеклопластик_750 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF0750; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF0750/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NF1000_Стеклопластик_1000 мм, КНС_ШтангаИзоляционная_DKC:NF1000_Стеклопластик_1000 мм:1014196
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF1000_Стеклопластик_1000 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF1000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NF1500_Стеклопластик_1500 мм, КНС_ШтангаИзоляционная_DKC:NF1500_Стеклопластик_1500 мм:1014204
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF1500_Стеклопластик_1500 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF1500; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF1500/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NF2000_Стеклопластик_2000 мм, КНС_ШтангаИзоляционная_DKC:NF2000_Стеклопластик_2000 мм:1014212
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF2000_Стеклопластик_2000 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF2000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF2000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг

# IfcBuildingElementProxy: NF3000_Стеклопластик_3000 мм, КНС_ШтангаИзоляционная_DKC:NF3000_Стеклопластик_3000 мм:1014220
In: Этаж 01
Type - Material: DKC_Сталь, DKC_Стеклопластик_Белый
Pset_BuildingElementProxyCommon - Reference: NF3000_Стеклопластик_3000 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NF3000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NF3000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC002673; Описание: Назначение: • монтаж молниеприемных стержней и проводников с соблюдением разделительного интервала (в соответствии с МЭК 62305-3). Характеристики: • крепление к вертикальной поверхности с помощью монтажной платы NF0002; • крепление прутка с помощью вкручиваемого держателя NF0001; • крепление стержней NL7100-NL7300 с помощью адаптера NG6608.; Комментарии к типоразмеру: Jupiter Система на основе изоляционных штанг
