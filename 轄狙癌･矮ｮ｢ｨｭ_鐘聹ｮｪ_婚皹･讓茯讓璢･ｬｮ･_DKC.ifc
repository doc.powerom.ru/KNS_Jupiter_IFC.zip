Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T18:59:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 18:59:13 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{E6C43D33-BBFE-495C-B89A-37EA2F70EC06}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 18:59:12 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 18:59:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 18:59:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3103CU_Медь, КНС_УниверсальныйСоединитель_DKC:NG3103CU_Медь:669751
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3103CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3103_Горячеоцинкованная сталь, КНС_УниверсальныйСоединитель_DKC:NG3103_Горячеоцинкованная сталь:669727
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3103_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: Горячеоцинкованная сталь (2)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • крестовое соединение прутка с прутком.; Комментарии к типоразмеру: Соединители Jupiter
Name (КНС_СоединительПрутокПруток_DKC:Горячеоцинкованная сталь:...) | ADSK_Код изделия
669511 | NG3104
669655 | NG3109

# IfcBuildingElementProxy: Медь (2)
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • крестовое соединение прутка с прутком.; Комментарии к типоразмеру: Соединители Jupiter
Name (КНС_СоединительПрутокПруток_DKC:Медь:...) | ADSK_Код изделия
669679 | NG3104CU
669703 | NG3109CU

# IfcDistributionPort (48)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_669411 | Механизмы Молниезащита_Пруток 12
3 x OutPort_669509 | Механизмы Молниезащита_Пруток 12
InPort_669413 | Механизмы Молниезащита_Пруток 12
InPort_669416 | Механизмы Молниезащита_Пруток 12
InPort_669509 | Механизмы Молниезащита_Пруток 12
OutPort_669525 | Механизмы Молниезащита_Пруток 12
InPort_669647 | Механизмы Молниезащита_Пруток 13
3 x OutPort_669653 | Механизмы Молниезащита_Пруток 13
InPort_669649 | Механизмы Молниезащита_Пруток 13
InPort_669651 | Механизмы Молниезащита_Пруток 13
InPort_669653 | Механизмы Молниезащита_Пруток 13
OutPort_669656 | Механизмы Молниезащита_Пруток 13
InPort_669671 | Механизмы Молниезащита_Пруток 15
3 x OutPort_669677 | Механизмы Молниезащита_Пруток 15
InPort_669673 | Механизмы Молниезащита_Пруток 15
InPort_669675 | Механизмы Молниезащита_Пруток 15
InPort_669677 | Механизмы Молниезащита_Пруток 15
OutPort_669680 | Механизмы Молниезащита_Пруток 15
InPort_669695 | Механизмы Молниезащита_Пруток 16
3 x OutPort_669701 | Механизмы Молниезащита_Пруток 16
InPort_669697 | Механизмы Молниезащита_Пруток 16
InPort_669699 | Механизмы Молниезащита_Пруток 16
InPort_669701 | Механизмы Молниезащита_Пруток 16
OutPort_669704 | Механизмы Молниезащита_Пруток 16
InPort_669719 | Механизмы Молниезащита_Пруток 17
3 x OutPort_669725 | Механизмы Молниезащита_Пруток 17
InPort_669721 | Механизмы Молниезащита_Пруток 17
InPort_669723 | Механизмы Молниезащита_Пруток 17
InPort_669725 | Механизмы Молниезащита_Пруток 17
OutPort_669728 | Механизмы Молниезащита_Пруток 17
InPort_669743 | Механизмы Молниезащита_Пруток 18
3 x OutPort_669749 | Механизмы Молниезащита_Пруток 18
InPort_669745 | Механизмы Молниезащита_Пруток 18
InPort_669747 | Механизмы Молниезащита_Пруток 18
InPort_669749 | Механизмы Молниезащита_Пруток 18
OutPort_669752 | Механизмы Молниезащита_Пруток 18

# IfcFlowFitting: NG3103CU_Медь, КНС_Крестовина_Пруток_Неспецифицируемое_DKC:NG3103CU_Медь:669749
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3103CU_Медь
Group: Механизмы Молниезащита_Пруток 18

# IfcFlowFitting: NG3103_Горячеоцинкованная сталь, КНС_Крестовина_Пруток_Неспецифицируемое_DKC:NG3103_Горячеоцинкованная сталь:669725
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3103_Горячеоцинкованная сталь
Group: Механизмы Молниезащита_Пруток 17

# IfcFlowFitting: NG3104CU_NG3109CU_Медь (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3104CU_NG3109CU_Медь
Name (КНС_Крестовина_Пруток_Неспецифицируемое_DKC:NG3104CU_NG3109CU_Медь:...) | Group
669677 | Механизмы Молниезащита_Пруток 15
669701 | Механизмы Молниезащита_Пруток 16

# IfcFlowFitting: NG3104_NG3109_Горячеоцинкованная сталь (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3104_NG3109_Горячеоцинкованная сталь
Name (КНС_Крестовина_Пруток_Неспецифицируемое_DKC:NG3104_NG3109_Горячеоцинкованная сталь:...) | Group
669509 | Механизмы Молниезащита_Пруток 12
669653 | Механизмы Молниезащита_Пруток 13

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC (24)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Горячеоцинкованный_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC:...) | Group
669411 | Механизмы Молниезащита_Пруток 12
669413 | Механизмы Молниезащита_Пруток 12
669416 | Механизмы Молниезащита_Пруток 12
669525 | Механизмы Молниезащита_Пруток 12
669647 | Механизмы Молниезащита_Пруток 13
669649 | Механизмы Молниезащита_Пруток 13
669651 | Механизмы Молниезащита_Пруток 13
669656 | Механизмы Молниезащита_Пруток 13
669671 | Механизмы Молниезащита_Пруток 15
669673 | Механизмы Молниезащита_Пруток 15
669675 | Механизмы Молниезащита_Пруток 15
669680 | Механизмы Молниезащита_Пруток 15
669695 | Механизмы Молниезащита_Пруток 16
669697 | Механизмы Молниезащита_Пруток 16
669699 | Механизмы Молниезащита_Пруток 16
669704 | Механизмы Молниезащита_Пруток 16
669719 | Механизмы Молниезащита_Пруток 17
669721 | Механизмы Молниезащита_Пруток 17
669723 | Механизмы Молниезащита_Пруток 17
669728 | Механизмы Молниезащита_Пруток 17
669743 | Механизмы Молниезащита_Пруток 18
669745 | Механизмы Молниезащита_Пруток 18
669747 | Механизмы Молниезащита_Пруток 18
669752 | Механизмы Молниезащита_Пруток 18
