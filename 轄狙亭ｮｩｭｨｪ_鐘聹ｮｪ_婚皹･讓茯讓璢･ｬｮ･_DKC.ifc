Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T18:56:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 18:56:16 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{7B20472E-327E-44F1-B7B9-B4DD28DB0418}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 18:56:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 18:56:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 18:56:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3103CU_Медь, КНС_УниверсальныйСоединитель_DKC:NG3103CU_Медь:666596
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3103CU_Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3103_Горячеоцинкованная сталь, КНС_УниверсальныйСоединитель_DKC:NG3103_Горячеоцинкованная сталь:660819
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3103_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3103CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3103/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14893; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное, крестовое и Т-образное соединение прутка диаметром 8 мм при монтаже молниеприемной сетки и системы токоотводов.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: Горячеоцинкованная сталь (2)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • крестовое соединение прутка с прутком.; Комментарии к типоразмеру: Соединители Jupiter
Name (КНС_СоединительПрутокПруток_DKC:Горячеоцинкованная сталь:...) | ADSK_Код изделия
649811 | NG3104
649813 | NG3109

# IfcBuildingElementProxy: Медь (2)
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: Медь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • крестовое соединение прутка с прутком.; Комментарии к типоразмеру: Соединители Jupiter
Name (КНС_СоединительПрутокПруток_DKC:Медь:...) | ADSK_Код изделия
660704 | NG3104CU
660705 | NG3109CU

# IfcDistributionPort (36)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_627085 | Механизмы Молниезащита_Пруток 6
2 x OutPort_636580 | Механизмы Молниезащита_Пруток 6
InPort_627100 | Механизмы Молниезащита_Пруток 6
InPort_636580 | Механизмы Молниезащита_Пруток 6
OutPort_636581 | Механизмы Молниезащита_Пруток 6
InPort_636683 | Механизмы Молниезащита_Пруток 14
2 x OutPort_636687 | Механизмы Молниезащита_Пруток 14
InPort_636685 | Механизмы Молниезащита_Пруток 14
InPort_636687 | Механизмы Молниезащита_Пруток 14
OutPort_636688 | Механизмы Молниезащита_Пруток 14
InPort_660688 | Механизмы Молниезащита_Пруток 8
2 x OutPort_660692 | Механизмы Молниезащита_Пруток 8
InPort_660690 | Механизмы Молниезащита_Пруток 8
InPort_660692 | Механизмы Молниезащита_Пруток 8
OutPort_660693 | Механизмы Молниезащита_Пруток 8
InPort_660696 | Механизмы Молниезащита_Пруток 11
2 x OutPort_660700 | Механизмы Молниезащита_Пруток 11
InPort_660698 | Механизмы Молниезащита_Пруток 11
InPort_660700 | Механизмы Молниезащита_Пруток 11
OutPort_660701 | Механизмы Молниезащита_Пруток 11
InPort_660811 | Механизмы Молниезащита_Пруток 9
2 x OutPort_660815 | Механизмы Молниезащита_Пруток 9
InPort_660813 | Механизмы Молниезащита_Пруток 9
InPort_660815 | Механизмы Молниезащита_Пруток 9
OutPort_660816 | Механизмы Молниезащита_Пруток 9
InPort_666588 | Механизмы Молниезащита_Пруток 10
2 x OutPort_666592 | Механизмы Молниезащита_Пруток 10
InPort_666590 | Механизмы Молниезащита_Пруток 10
InPort_666592 | Механизмы Молниезащита_Пруток 10
OutPort_666593 | Механизмы Молниезащита_Пруток 10

# IfcFlowFitting: NG3103CU_Медь, КНС_Тройник_Пруток_Неспецифицируемое_DKC:NG3103CU_Медь:666592
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3103CU_Медь
Group: Механизмы Молниезащита_Пруток 10

# IfcFlowFitting: NG3103_Горячеоцинкованная сталь, КНС_Тройник_Пруток_Неспецифицируемое_DKC:NG3103_Горячеоцинкованная сталь:660815
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3103_Горячеоцинкованная сталь
Group: Механизмы Молниезащита_Пруток 9

# IfcFlowFitting: NG3104CU_NG3109CU_Медь (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3104CU_NG3109CU_Медь
Name (КНС_Тройник_Пруток_Неспецифицируемое_DKC:NG3104CU_NG3109CU_Медь:...) | Group
660692 | Механизмы Молниезащита_Пруток 8
660700 | Механизмы Молниезащита_Пруток 11

# IfcFlowFitting: NG3104_NG3109_Горячеоцинкованная сталь (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3104_NG3109_Горячеоцинкованная сталь
Name (КНС_Тройник_Пруток_Неспецифицируемое_DKC:NG3104_NG3109_Горячеоцинкованная сталь:...) | Group
636580 | Механизмы Молниезащита_Пруток 6
636687 | Механизмы Молниезащита_Пруток 14

# IfcFlowSegment: Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC (18)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Пруток_Горячеоцинкованный_8/10мм_DKC
Name (Воздуховод круглого сечения:КНС_Пруток_Горячеоцинкованный_8/10мм_DKC:...) | Group
627085 | Механизмы Молниезащита_Пруток 6
627100 | Механизмы Молниезащита_Пруток 6
636581 | Механизмы Молниезащита_Пруток 6
636683 | Механизмы Молниезащита_Пруток 14
636685 | Механизмы Молниезащита_Пруток 14
636688 | Механизмы Молниезащита_Пруток 14
660688 | Механизмы Молниезащита_Пруток 8
660690 | Механизмы Молниезащита_Пруток 8
660693 | Механизмы Молниезащита_Пруток 8
660696 | Механизмы Молниезащита_Пруток 11
660698 | Механизмы Молниезащита_Пруток 11
660701 | Механизмы Молниезащита_Пруток 11
660811 | Механизмы Молниезащита_Пруток 9
660813 | Механизмы Молниезащита_Пруток 9
660816 | Механизмы Молниезащита_Пруток 9
666588 | Механизмы Молниезащита_Пруток 10
666590 | Механизмы Молниезащита_Пруток 10
666593 | Механизмы Молниезащита_Пруток 10
