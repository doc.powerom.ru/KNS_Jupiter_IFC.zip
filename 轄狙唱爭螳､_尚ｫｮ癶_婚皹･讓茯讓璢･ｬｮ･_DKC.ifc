Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:04:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:04:47 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B5886942-DC56-473A-91FD-99748DB29406}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:04:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:04:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:04:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG3105CU_Медь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105CU_Медь_80х70 мм:822685
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3105CU_Медь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_СоединительПолосаПолоса_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:822684
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106CU_Медь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106CU_Медь_100х100 мм:822687
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NG3106CU_Медь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcBuildingElementProxy: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_СоединительПолосаПолоса_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:822686
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG3106; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG3106/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • параллельное и крестовое соединение полосы c полосой.; Комментарии к типоразмеру: Соединители Jupiter

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_822642 | Механизмы Молниезащита_Полоса 22
2 x OutPort_822680 | Механизмы Молниезащита_Полоса 22
InPort_822643 | Механизмы Молниезащита_Полоса 23
2 x OutPort_822681 | Механизмы Молниезащита_Полоса 23
InPort_822644 | Механизмы Молниезащита_Полоса 24
2 x OutPort_822682 | Механизмы Молниезащита_Полоса 24
InPort_822645 | Механизмы Молниезащита_Полоса 25
2 x OutPort_822683 | Механизмы Молниезащита_Полоса 25
InPort_822646 | Механизмы Молниезащита_Полоса 22
InPort_822649 | Механизмы Молниезащита_Полоса 23
InPort_822652 | Механизмы Молниезащита_Полоса 24
InPort_822655 | Механизмы Молниезащита_Полоса 25

# IfcFlowFitting: NG3105CU_Медь_80х70 мм, КНС_Переход_Полоса_Неспецифицируемое_DKC:NG3105CU_Медь_80х70 мм:822681
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105CU_Медь_80х70 мм
Group: Механизмы Молниезащита_Полоса 23

# IfcFlowFitting: NG3105_Горячеоцинкованная сталь_80х70 мм, КНС_Переход_Полоса_Неспецифицируемое_DKC:NG3105_Горячеоцинкованная сталь_80х70 мм:822680
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3105_Горячеоцинкованная сталь_80х70 мм
Group: Механизмы Молниезащита_Полоса 22

# IfcFlowFitting: NG3106CU_Медь_100х100 мм, КНС_Переход_Полоса_Неспецифицируемое_DKC:NG3106CU_Медь_100х100 мм:822683
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106CU_Медь_100х100 мм
Group: Механизмы Молниезащита_Полоса 25

# IfcFlowFitting: NG3106_Горячеоцинкованная сталь_100х100 мм, КНС_Переход_Полоса_Неспецифицируемое_DKC:NG3106_Горячеоцинкованная сталь_100х100 мм:822682
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: NG3106_Горячеоцинкованная сталь_100х100 мм
Group: Механизмы Молниезащита_Полоса 24

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC
Name (Воздуховод прямоугольного сечения:КНС_Полоса_Горячеоцинкованная_25х4/40х4/40x5/50х5мм_DKC:...) | Group
822642 | Механизмы Молниезащита_Полоса 22
822643 | Механизмы Молниезащита_Полоса 23
822644 | Механизмы Молниезащита_Полоса 24
822645 | Механизмы Молниезащита_Полоса 25
822646 | Механизмы Молниезащита_Полоса 22
822649 | Механизмы Молниезащита_Полоса 23
822652 | Механизмы Молниезащита_Полоса 24
822655 | Механизмы Молниезащита_Полоса 25
