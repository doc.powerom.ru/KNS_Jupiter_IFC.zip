Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:11:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:11:33 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4AD42404-75F4-4527-83B4-ACE871E51926}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:11:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:11:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:11:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NG6606_Горячеоцинкованная сталь (5)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NG6606_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG6606; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6606/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: • подключение молниеприемной сетки или токоотводов к молниеприемному стержню.; Комментарии к типоразмеру: Молниеприемники Jupiter
Name (КНС_СоединительПроводникаДляМолниеприемника_DKC:NG6606_Горячеоцинкованная сталь:...)
708819
708909
708953
709005
709062

# IfcBuildingElementProxy: NG6607_Алюминий (5)
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: NG6607_Алюминий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NG6607; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NG6607/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000514; Описание: Назначение: ● подключение ESE молниеприемника к мачтам 5–6 метров. Характеристики: ● ввинчивается в основание ESE молниеприемника и крепится к мачтам 5–6 метров.; Комментарии к типоразмеру: Jupiter Элементы для монтажа
Name (КНС_СоединительESEМолниеприемникМачта_DKC:NG6607_Алюминий:...)
1160219
1160221
1160225
1160227
1161040

# IfcBuildingElementProxy: NI0015_Нержавеющая сталь V4A (5)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V4A
Pset_BuildingElementProxyCommon - Reference: NI0015_Нержавеющая сталь V4A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NI0015; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NI0015/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • дополнительная защита от прямых ударов молнии. Характеристики: • данные заявлены согласно стандартам NFC 17-102:2011, МЭК 62305-2.; Комментарии к типоразмеру: Jupiter Активные молниеприемники
Name (КНС_ESEМолниеприемник_DKC:NI0015_Нержавеющая сталь V4A:...)
1160220
1160222
1160226
1160228
1161041

# IfcBuildingElementProxy: NL0500_Бетон_40кг (15)
In: Этаж 01
Type - Material: DKC_Бетон
Pset_BuildingElementProxyCommon - Reference: NL0500_Бетон_40кг
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL0500; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL0500/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Описание: Назначение • установка стержневых молниеприемников на плоских горизонтальных поверхностях. Особенности • содержит две точки подключения с резьбой М16 для ввинчивания молниеприемного стержня и специального соединителя; • точки подключения соединены металлической пластиной внутри основания; Комментарии к типоразмеру: Молниеприемники Jupiter
Name (КНС_ОсновниеБетонное_DKC:NL0500_Бетон_40кг:...)
708814
708816
708817
708904
708906
708907
708948
708950
708951
709000
709002
709003
709057
709059
709060

# IfcBuildingElementProxy: NL0700_Горячеоцинкованная сталь (5)
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NL0700_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL0700; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL0700/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC001626; Описание: Назначение: • установка молниеприемных мачт длиной 5-7 метров. Характеристики: • устанавливается на три бетонных основания NL0500; • крепежный материал входит в комплект.; Комментарии к типоразмеру: Молниеприемники Jupiter
Name (КНС_ТреногаДляМолниеприемнойМачты_DKC:NL0700_Горячеоцинкованная сталь:...)
708815
708905
708949
709001
709058

# IfcBuildingElementProxy: NL5000CU_Медь_5м, КНС_МачтаМолниеприемная_DKC:NL5000CU_Медь_5м:708818
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL5000CU_Медь_5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5000CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5000CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL5000_СтальНержавеющая_5м, КНС_МачтаМолниеприемная_DKC:NL5000_СтальНержавеющая_5м:708908
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL5000_СтальНержавеющая_5м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL5000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL5000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6000CU_Медь_6м, КНС_МачтаМолниеприемная_DKC:NL6000CU_Медь_6м:708952
In: Этаж 01
Type - Material: DKC_Медь
Pset_BuildingElementProxyCommon - Reference: NL6000CU_Медь_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6000CU; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6000CU/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL6000_СтальНержавеющая_6м, КНС_МачтаМолниеприемная_DKC:NL6000_СтальНержавеющая_6м:709004
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL6000_СтальНержавеющая_6м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL6000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL6000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter

# IfcBuildingElementProxy: NL7000_СтальНержавеющая_7м, КНС_МачтаМолниеприемная_DKC:NL7000_СтальНержавеющая_7м:709061
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая
Pset_BuildingElementProxyCommon - Reference: NL7000_СтальНержавеющая_7м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NL7000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NL7000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000505; Описание: Назначение: • монтаж молниеприемников.; Комментарии к типоразмеру: Молниеприемники Jupiter
