Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:30:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:30:55 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DBB22A9B-217E-4222-AA9B-CEE389153264}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:30:54 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:30:54 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:30:54 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NX1211, КНС_УЗИП_классI+II_DKC:NX1211:1037655
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1211
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1211; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1211/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1212, КНС_УЗИП_классI+II_DKC:NX1212:1038065
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1212
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1212; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1212/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1213, КНС_УЗИП_классI+II_DKC:NX1213:1038073
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1213
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1213; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1213/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1221, КНС_УЗИП_классI+II_DKC:NX1221:1038081
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1221
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1221; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1221/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1222, КНС_УЗИП_классI+II_DKC:NX1222:1038089
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1222
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1222; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1222/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1241, КНС_УЗИП_классI+II_DKC:NX1241:1038097
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1241
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: NX1241; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1241/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II

# IfcBuildingElementProxy: NX1242, КНС_УЗИП_классI+II_DKC:NX1242:1038107
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: NX1242
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NX1241; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NX1242/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000941; Описание: Назначение: • установка на уровне главного распределительного щита. Характеристики: • УЗИП на основе газонаполненных разрядников и оксидно-цинковых варисторов рекомендуется к применению в любых зданиях и сооружениях, подверженным ударам молнии.; Комментарии к типоразмеру: Jupiter УЗИП класс I+II
