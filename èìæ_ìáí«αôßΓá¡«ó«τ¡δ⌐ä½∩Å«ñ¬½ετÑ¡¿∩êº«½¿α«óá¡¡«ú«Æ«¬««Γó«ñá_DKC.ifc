Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:21:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:21:12 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{41254946-41F5-45BF-834A-125BE01F90E2}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:21:11 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:21:12 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:21:12 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: NK0001_Сталь нержавеющая V2A, КНС_НаборУстановочныйДляПодключенияИзолированногоТокоотвода_DKC:NK0001_Сталь нержавеющая V2A:1128431
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_V2A
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: NK0001_Сталь нержавеющая V2A
