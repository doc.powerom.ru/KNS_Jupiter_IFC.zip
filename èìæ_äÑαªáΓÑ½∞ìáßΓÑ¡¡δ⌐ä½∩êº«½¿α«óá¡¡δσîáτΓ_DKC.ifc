Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-08-29T19:23:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 29 19:23:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{97FCE2A1-CE7A-4950-B8BC-44C51C4A9256}\ifc * Database version: 5507 * Database creation date: Sun Aug 29 19:23:55 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 29 19:23:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 29 19:23:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: NK3105_Горячеоцинкованная сталь, КНС_ДержательНастенныйДляИзолированныхМачт_DKC:NK3105_Горячеоцинкованная сталь:1005956
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_BuildingElementProxyCommon - Reference: NK3105_Горячеоцинкованная сталь
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: NK3105; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/571/NK3105/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Охранная сигнализация; ETIM Article Class: EC000509; Описание: Назначение: • крепление мачты к различным конструкциям. Характеристики: • крепление к различным конструкциям на хомуты NK3103/NK3104; • возможно крепление на вертикальную поверхность с помощью шпильки; • возможно крепление обычных мачт 5–7 м; • для установки молниеприемника необходимо использовать минимум 2 держателя.; Комментарии к типоразмеру: Jupiter Система на основе изолированного токоотвода
